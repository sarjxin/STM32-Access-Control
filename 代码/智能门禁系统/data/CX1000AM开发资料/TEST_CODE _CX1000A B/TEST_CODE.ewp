# IAR project TEST_CODE.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: F:\Products\Yuyin module\TEST_CODE\inc; F:\Products\Yuyin module\TEST_CODE\src; F:\Products\Yuyin module\TEST_CODE\LIB\inc; F:\Products\Yuyin module\TEST_CODE\LIB\src
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group INC
    inc/: clk.h delay.h LED.H main.h stm8s_conf.h stm8s_it.h uart.h
  group SRC
    src/: clk.c delay.c LED.C main.c stm8s_it.c uart.c
